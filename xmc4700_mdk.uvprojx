# Keil uVision project xmc4700_mdk.uvprojx, settings and files
target application RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.12.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xmc4700_mdk
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC4700_F144x2048, XMC_ETH_PHY_KSZ8081RNB
  c include: ..\xmc4700_mdk;.\httpserver;.\lwip\include;.\lwip\include\ipv4;.\lwip\include\netif;.\lwip\port\cmsis-rtos\include;.\lwip\include\posix;.\lwip\include\posix\sys;.\lwip\port\cmsis-rtos\netif
  memory RVCT3: ROM 0x1ffe8000 size 0x18000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  group xmc4700_mdk
    ./: main.c led.c xmc4700_nvic_handler.c
  group http_server
    ./httpserver/: httpserver-netconn.c
  group lwip_api
    ./lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_core
    ./lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip_netif
    ./lwip/netif/: etharp.c slipif.c
    ./lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip_port
    ./lwip/port/cmsis-rtos/: sys_arch.c
    ./lwip/port/cmsis-rtos/netif/: ethernetif.c
  group doc
    ./: README.md
target application Flash Cached (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.12.0
  cpu: as above
  output: xmc4700_mdk
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC4700_F144x2048,XMC_ETH_PHY_KSZ8031RNL
  c include: ..\xmc4700_mdk;.\httpserver;.\lwip\include;.\lwip\include\ipv4;.\lwip\include\netif;.\lwip\port\cmsis-rtos\include;.\lwip\port\cmsis-rtos\netif;.\lwip\include\posix;.\lwip\include\posix\sys
  memory RVCT3: ROM 0x1ffe8000 size 0x18000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
target application Flash Uncached (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.12.0
  cpu: as above
  output: xmc4700_mdk
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC4700_F144x2048
  c include: ..\xmc1100_prj\coremark_v1.0;..\xmc1100_prj\coremark_v1.0\xmc4700;..\xmc4700_mdk
  memory RVCT3: ROM 0x1ffe8000 size 0x18000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.1, Device:RTE_Device 1.1.0, Device:Startup 2.2.4, Device:XMClib:ETH_MAC 2.1.22, Device:XMClib:ETH_PHY 2.1.22, Device:XMClib:GPIO 2.1.22, Device:XMClib:SCU 2.1.22, Device:XMClib:UART 2.1.22, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
